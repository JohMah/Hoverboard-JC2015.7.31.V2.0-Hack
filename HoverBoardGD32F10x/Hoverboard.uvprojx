# Keil uVision project Hoverboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoverboard +hex
  c flags: Optim=3 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -ferror-limit=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c bldc.c setup.c it.c comms.c commsBluetooth.c commsSteering.c commsMasterSlave.c led.c
  group Inc
    ./Inc/: defines.h config.h bldc.h setup.h it.h comms.h commsBluetooth.h commsSteering.h commsMasterSlave.h led.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:DBG 2.0.1, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_StdPeripherals:WWDGT 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
